# Keil uVision project Pulling force collection.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Pulling force collection +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 delay.c display.c hx711.c i2c.c init.c key.c main.c oled.c oled_display.c pit.c read voltage value.c uart.c
